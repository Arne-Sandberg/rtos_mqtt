# Keil uVision project FreeRTOS_v9.0.0.uvproj, settings and files
target FreeRTOS_MQTT (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: FreeRTOS_v9.0.0.axf +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\CMSIS;..\BSP;..\FWlib\inc;..\FWlib\src;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\third_party\FatFS\source;..\third_party\minini_12b;..\STM32_ETH_Driver\inc;..\third_party\lwip-1.4.1\src\include;..\third_party\lwip-1.4.1\src\include\ipv4;..\APP\MQTTClient;..\APP;..\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../BSP/: main.c stm32f10x_it.c STM32F10x.s timertest.c serial.c utils.c sdcard.c spi.c common.c netconf.c stm32f107.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c rtos_timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group third_party/FatFS
    ../third_party/FatFS/source/: diskio.c ff.c
  group third_party/minIni
    ../third_party/minini_12b/: minIni.c
  group ETH
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group third_party/LwIP
    ../third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../third_party/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../third_party/lwip-1.4.1/src/include/arch/: sys_arch.c
  group APP
    ../APP/: MqttTask.c configApp.c collectData.c loggerManage.c
  group APP/MQTTClient
    ../APP/MQTTClient/: MQTTClient.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTFreeRTOSImpl.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group I2C
    ../I2C/: i2c_slave.c i2c_slave_port.c I2c_master.c
